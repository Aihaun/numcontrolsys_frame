# Keil uVision project 8axis.uvprojx, settings and files
target 8Axis (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: App +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ..\User\Objects\App.bin ..\User\Objects\App.axf
  AfterMake: Encryption ..\User\Objects\App.bin ..\User\Objects\download.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_USB_OTG_FS,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1,ARM
  c include: ..\APP;..\LIB;..\InterLayer;..\APP\Config;..\APP\Tool;..\App.drv
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: AppInit.c FSM.c Reset.c Logic.c Teach.c Motion.c MainTask.c
  group App.drv
    ../App.drv/: HoleShape.c SlotShape.c HingeShape.c ChangerOperate.c SetDoorSize.c SetTool.c
  group Tool
    ../APP/Tool/: Tool.c AxisMove.c JogClass.c UserTool.c
  group Config
    ../APP/: main.c
    ../APP/Config/: AxisConfig.c bsp_config.c InterLayer.c
  group LIB
    ../LIB/: lock.h can_master.h can_master.lib Algorithm.h Algorithm_ver_00_01_00.lib Interlayer_config.h INTERLAYER_VER01_10_04.lib BspLib.h BspLibA8I24O24_V00.01.00.lib
  group Startup
    ./: startup_stm32f40_41xxx.s
  group Doc
    ../: Readme.txt
